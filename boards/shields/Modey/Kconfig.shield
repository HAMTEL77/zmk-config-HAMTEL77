## boards/shields/Modey/Kconfig.shield
```kconfig
config SHIELD_MOD_R
    def_bool $(shields_list_contains,Modey_R)

config SHIELD_MOD_L
    def_bool $(shields_list_contains,Modey_L)
```
